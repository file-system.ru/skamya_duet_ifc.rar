Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Номер проекта
Time: 2018-01-15T12:10:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.0.490.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 15 12:10:09 2018 * Host: DESKTOP-9RIKPKU * Database: C:\Users\voins\AppData\Local\Temp\{AAE40937-5F40-4F4B-A92B-2D535A47C7D0}\ifc * Database version: 5507 * Database creation date: Mon Jan 15 12:10:09 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 15 12:10:09 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 15 12:10:09 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 45, 25, 90026; RefLongitude: 37, 36, 54, 74707; RefElevation: 0 mm
Прочее - Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Категория: Сведения о проекте; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Прочее - Категория: Сведения о проекте; Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Верхний брус 8 мм; Семейство: Уровень: Верхний брус 8 мм; Семейство и типоразмер: Уровень: Верхний брус 8 мм; Тип: Уровень: Верхний брус 8 мм
Идентификация - Имя типа: Верхний брус 8 мм; Имя: Уровень 1; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: Заголовок уровня - Окружность: Заголовок уровня - Окружность; Образец линий: Центр; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: no; Цвет: 0

# IfcBuildingElementProxy: "Квант" Белый шелк, skamya_kvant:"Квант" Белый шелк:409975
In: Уровень 1
Type - Material: Настил, Очаковский_Белый_Шелк
Type - Данные - Объем бетона: 0.044 m3
Type - Идентификация - Имя типа: "Квант" Белый шелк
Type - Материалы и отделка - Материал: Очаковский_Белый_Шелк; Материал настила: Настил
Type - Прочее - Категория: Антураж; Имя семейства: skamya_kvant
Type - Размеры - Высота: 400 mm; Длина: 1540 mm; Ширина: 420 mm
Type - Текст - Наименование: Скамья "Квант"; Производитель: ГК Очаковский комбинат ЖБИ
Pset_BuildingElementProxyCommon - Reference: "Квант" Белый шелк
Данные - Водонепроницаемость: W8; Защитное покрытие: 1.04; Класс бетона: В30; Масса: 38; Морозостойкость: F150; Площадь: 1.137 m2
Зависимости - Основа: Уровень : Уровень 1; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Уровень 1
Прочее - Высота сиденья: 375 mm; Код типа: skamya_kvant: "Квант" Белый шелк; Семейство: skamya_kvant: "Квант" Белый шелк; Семейство и типоразмер: skamya_kvant: "Квант" Белый шелк; Тип: skamya_kvant: "Квант" Белый шелк; Ширина сечения стойки: 130 mm
Размеры - Объем: 0.25872 m3; Площадь: 1.4308 m2
Стадии - Стадия возведения: Новая конструкция
Текст - Описание изделия: Вазон «Твист» изготовлен по новейшей бесшовной технологии и имеет необычную форму, позволяющую отойти от строгих прямых линий, характерных для изделий из бетона.Компактность вазона позволит использовать его в условиях ограниченного пространства,а интересная форма никого не оставит равнодушным.
